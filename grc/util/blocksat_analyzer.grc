<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>blocksat_analyzer</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Analyzes the spectral density and the constellation of the Blockstream Satellite signal.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Satellite Receiver Signal Analyzer</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>bpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>const_order</value></param>
<param><key>value</key><value>pow(2,constellation_obj.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>constellation_obj</value></param>
<param><key>value</key><value>qpsk_const if (modulation == "qpsk") else bpsk_const</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_rrc_taps</value></param>
<param><key>value</key><value>rrc_delay * int(sps * pcs_n_filters)</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk_const</value></param>
<param><key>const_points</key><value>[1,- 1]</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>[0,1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_delay</value></param>
<param><key>value</key><value>int(round(-44*excess_bw + 33))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(pcs_n_filters, pcs_n_filters * sps, 1.0, excess_bw, n_rrc_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sym_rate * sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>156.25e3</value></param>
</block>
<block>
<key>variable_rx_logger</key>
<param><key>id</key><value>variable_rx_logger_0</value></param>
<param><key>cfo_rec</key><value>self.digital_fll_band_edge_cc_1</value></param>
<param><key>decoder</key><value>None</value></param>
<param><key>enabled_start</key><value>True</value></param>
<param><key>frame_synchronizer</key><value>None</value></param>
<param><key>value</key><value>0</value></param>
<param><key>ber_log_period</key><value>0</value></param>
<param><key>cfo_log_period</key><value>10</value></param>
<param><key>frame_sync_log_period</key><value>0</value></param>
<param><key>snr_log_period</key><value>1</value></param>
<param><key>snr_meter</key><value>self.blocksat_mer_measurement_pre_frame_sync</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>agc_rate</value></param>
<param><key>label</key><value>the update rate of the automatic gain control (AGC) loop.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e-4</value></param>
</block>
<block>
<key>blocksat_agc_cc</key>
<param><key>id</key><value>blocksat_agc_cc_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>agc_rate</value></param>
<param><key>reference</key><value>1.0</value></param>
</block>
<block>
<key>blocksat_mer_measurement</key>
<param><key>id</key><value>blocksat_mer_measurement_pre_frame_sync</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>M</key><value>int(const_order)</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>comment</key><value>Carrier Phase Recovery</value></param>
<param><key>w</key><value>2*pi/loopbw</value></param>
<param><key>order</key><value>2**constellation_obj.bits_per_symbol()</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_1</value></param>
<param><key>comment</key><value>Coarse Carrier Freq. Recovery</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>w</key><value>fllbw</value></param>
<param><key>filter_size</key><value>rrc_delay * int(sps) + 1</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>comment</key><value>Symbol Timing Recovery</value></param>
<param><key>filter_size</key><value>pcs_n_filters</value></param>
<param><key>init_phase</key><value>pcs_n_filters/2</value></param>
<param><key>loop_bw</key><value>pcsbw</value></param>
<param><key>max_dev</key><value>pcs_max_rate_dev</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>fll_d_phase_null_sink</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>fll_d_phase_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>fll_error_null_sink</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fllbw</value></param>
<param><key>label</key><value>Frequency-locked Loop Bandwidth</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>RF Center Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RTL-SDR radio-frequency (RF) gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40.0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import *</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>loopbw</value></param>
<param><key>label</key><value>Costas Loop Bandwidth</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>modulation</value></param>
<param><key>label</key><value>Modulation (qpsk or bpsk)</value></param>
<param><key>short_id</key><value>m</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"qpsk"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pcs_max_rate_dev</value></param>
<param><key>label</key><value>maximum allowed rate deviation for the control loop of the polyphase symbol timing synchronizer.</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>pi/64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pcs_n_filters</value></param>
<param><key>label</key><value>number of parallel filters in the polyphase clock sync block.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pcsbw</value></param>
<param><key>label</key><value>Polyphase Clock Sync Loop Bandwidth</value></param>
<param><key>short_id</key><value>w</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2*pi/50</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_overview</value></param>
<param><key>gui_hint</key><value>tabs@0:2,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>name</key><value>"Constellation"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_overview</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:0,0,1,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>alpha1</key><value>0.5</value></param>
<param><key>name</key><value>"Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_HANN</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_mer_pre_fs</value></param>
<param><key>avg</key><value>0.001</value></param>
<param><key>gui_hint</key><value>tabs@0:2,2,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>Input to Frame Synchronizer</value></param>
<param><key>max</key><value>12</value></param>
<param><key>min</key><value>3</value></param>
<param><key>name</key><value>"Modulation Error Ratio (dB)"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_signal_level</value></param>
<param><key>gui_hint</key><value>tabs@0:2,1,2,1</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_VERT</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>RMS Value</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>name</key><value>"Signal Level"</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_overview</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@0:0,2,1,2</value></param>
<param><key>int_max</key><value>-20</value></param>
<param><key>int_min</key><value>-50</value></param>
<param><key>name</key><value>"Spectrogram"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rtl_if_gain</value></param>
<param><key>label</key><value>RTL-SDR intermediate frequency (IF) gain in dB (E4000 tuner only).</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20.0</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>rtl_if_gain</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Oversampling Ratio</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>label0</key><value>Overview</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>qtgui_number_sink_signal_level</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_overview</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_agc_cc_0</source_block_id><sink_block_id>qtgui_waterfall_sink_overview</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocksat_mer_measurement_pre_frame_sync</source_block_id><sink_block_id>qtgui_number_sink_mer_pre_fs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocksat_mer_measurement_pre_frame_sync</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_const_sink_overview</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>fll_error_null_sink</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>fll_d_phase_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_1</source_block_id><sink_block_id>fll_d_phase_null_sink</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocksat_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
